# Keil uVision project STM32HalPoject.uvprojx, settings and files
target STM32HalPoject (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32HalPoject +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__CC_ARM,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../bsp;../App;../mathlib;../mathlib/Algorithm;../dsp/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/UserBsp
    ../bsp/: bsp_bmi088.c bsp_delay.c bsp_dwt.c bsp_flash.c bsp_iic.c bsp_imu.c bsp_ist8310.c bsp_JY901.c bsp_spi.c bsp_uart.c bsp_can.c bsp_remote_ET08.c bsp_remote_ET08.h
  group Application/AppCtrl
    ../App/: BMI088_Read.c Comm_Task.c IMU_AHRSupdate.c IST8310_Read.c Status_Task.c
  group Application/Mathlib
    ../mathlib/: Calibration.c data_processing.c Filter.c kalman_filter.c KalmanFilter.c pid.c
    ../mathlib/Algorithm/: QuaternionEKF.c
  group Application/Dsp
    ../dsp/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0
